# Keil uVision project BootLoader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DaqBootLoader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output proj.bin Output\DaqBootLoader.axf
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SourceFiles\inc;..\StartupFiles\INC;..\STM32_StdPeripLibrary\inc;..\Utilities;..\StartupFiles
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SourceFiles
    ../SourceFiles/src/: stm32fxxx_it.c Bootloader.c Version.c AppJump.c BootCmd.c BootEntry.c Crc.c Debug.c FlashIf.c FwValidate.c Protocol.c SysTick.c Uart.c
  group STM32_StdPeripLibrary
    ../STM32_StdPeripLibrary/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartupFiles
    ../StartupFiles/SRC/: system_stm32f10x.c
    ../StartupFiles/: startup_stm32f10x_cl.s
